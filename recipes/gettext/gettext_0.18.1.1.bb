require gettext.inc
