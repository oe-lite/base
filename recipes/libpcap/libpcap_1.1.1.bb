require libpcap.inc

PR_append = ".1"

SRC_URI += "file://ieee80215-arphrd.patch;patch=1"
