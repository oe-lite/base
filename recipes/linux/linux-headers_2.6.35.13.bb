require ${PN}-longterm.inc
