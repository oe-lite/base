require libpng.inc
