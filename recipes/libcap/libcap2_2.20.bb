require ${BPN}.inc

SRC_URI += "file://make.patch"
SRC_URI += "file://make-no-raise-setfcap.patch"
