require dropbear.inc

PR="r4"
