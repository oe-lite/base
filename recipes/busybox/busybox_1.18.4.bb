require busybox.inc

SRC_URI_append += "file://udhcp-simple-script-route-del-dev-null.patch"
