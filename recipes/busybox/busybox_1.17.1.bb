require busybox.inc

INC_PR = ".1"

SRC_URI_+= "file://udhcp-simple-script-route-del-dev-null.patch;patch=1"
