require lzo.inc

SRC_URI += "file://autofoo.patch"
SRC_URI += "file://acinclude.m4"
