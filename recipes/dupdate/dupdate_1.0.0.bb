require dupdate.inc

SRCREV = "v${PV}"
