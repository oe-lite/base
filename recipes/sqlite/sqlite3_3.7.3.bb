require sqlite3.inc

SRC_URI += "file://libtool.patch"
