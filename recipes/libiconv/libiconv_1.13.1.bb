require libiconv.inc

PR_append = ".0"

LICENSE = "GPLv3 LGPLv2"
