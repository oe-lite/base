include boost.inc

require conf/fetch/sourceforge.conf
SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost_${BOOST_VER}.tar.bz2"
