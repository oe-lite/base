include boost.inc

PR = "${INC_PR}.0"

SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost_${BOOST_VER}.tar.bz2"
