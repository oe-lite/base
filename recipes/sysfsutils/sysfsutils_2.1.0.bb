require sysfsutils.inc

SRC_URI += "file://get_mnt_path_check.patch"
