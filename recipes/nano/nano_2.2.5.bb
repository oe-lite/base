include nano.inc

SRC_URI += "file://ncursesw.includedir.patch;patch=1"
