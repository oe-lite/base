require ${BPN}.inc

SRC_URI += "file://nobash.patch"
