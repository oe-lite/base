require ntp.inc

SRC_URI += "\
   file://ntp-4.2.4_p6-nano.patch \
    file://tickadj.c.patch \
"
