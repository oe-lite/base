require genext2fs.inc

SRC_URI += "file://volume.patch"
